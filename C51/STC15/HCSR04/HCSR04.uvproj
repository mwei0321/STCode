# Keil uVision project HCSR04.uvproj, settings and files
target HC-SR04 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HCSR04 +hex
  c flags: Optimize=8 SizeSpeed=1
  group HC-SR04
    ./: rcwl-1601.c
