# Keil uVision project TM1620.uvproj, settings and files
target TM1620 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: TM1620 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
