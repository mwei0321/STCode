# Keil uVision project LCD12864.uvproj, settings and files
target LCD12864 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LCD12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD12864
    ./: 12864.C
