# Keil uVision project DS18B20.uvproj, settings and files
target ds18b20 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c DS18B20.C
