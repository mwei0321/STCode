# Keil uVision project DS3231.uvproj, settings and files
target DS3231 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS3231 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: test.c init.h
